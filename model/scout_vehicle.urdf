Commit message: simple control

File: model/scout_vehicle.urdf (robot description, URDF)
Before this commit: robot my_robot, 8 links, 7 joints
Links:
- link velodyne: geometry visual mesh filename=package://isaac-scout-ros2/model/meshes/VLP16_scan.dae
